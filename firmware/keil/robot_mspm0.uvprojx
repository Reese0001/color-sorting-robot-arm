# Keil uVision project robot_mspm0.uvprojx, settings and files
target MSPM0G3507_Bench (6070000::V6.7::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20200000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: robot_mspm0 +hex
  c flags: Optim=2 uC99=1 v6Lang=1 wLevel=3
  c define: __MSPM0G3507__
  c misc: -std=c99
  c include: ..\include;..\lib\k230_protocol;..\lib\hiwonder_bus;..\vendor\mspm0_sdk\source;..\vendor\mspm0_sdk\source\third_party\CMSIS\Core\Include
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20200000 size 0x8000
  scatter file: .\robot_mspm0.sct
  group Application
    ../src/: main.c board_mspm0.c
    ../include/: app_config.h board.h
  group Robot workflow
    ../src/: robot_config.c robot_workflow.c robot_console.c
    ../include/: robot_config.h robot_workflow.h robot_console.h
  group Protocols
    ../lib/k230_protocol/: k230_protocol.c
    ../lib/hiwonder_bus/: hiwonder_bus.c
  group TI DriverLib
    ../vendor/mspm0_sdk/source/ti/driverlib/: dl_uart.c dl_timer.c
  group Startup
    ./: startup_mspm0g350x_uvision.s
